# Keil uVision project STM32F103ZET6.uvprojx, settings and files
target M3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6 +hex
  AfterMake: D:\study\Keil_v5\Arm\ARMCC\bin\fromelf.exe   --bin -o  ..\..\Output\STM32F103ZET6.bin ..\..\Output\STM32F103ZET6.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\Drivers;..\..\Drivers\BSP;..\..\Drivers\BSP\inc;..\..\Drivers\Libraries;..\..\Drivers\Libraries\CMSIS;..\..\Drivers\Libraries\FWlib;..\..\Drivers\Libraries\FWlib\inc;..\..\Drivers\SYSTEM;..\..\Drivers\SYSTEM\inc;..\..\Middlewares\Update;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
    ../../Drivers/Libraries/CMSIS/: core_cm3.c
  group User
    ../../User/: main.c stm32f10x_it.c
    ../../Drivers/Libraries/CMSIS/: system_stm32f10x.c
  group System
    ../../Drivers/SYSTEM/src/: sys.c delay.c usart.c
  group STM32F10x_StdPeriph_Driver
    ../../Drivers/Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_usart.c stm32f10x_flash.c
  group BSP
    ../../Drivers/BSP/src/: led.c key.c
  group Update
    ../../Middlewares/Update/: update.c
  group Readme
    ../../: readme.txt
