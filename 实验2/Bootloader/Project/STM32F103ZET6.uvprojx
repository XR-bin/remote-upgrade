# Keil uVision project STM32F103ZET6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6 +hex
  AfterMake: D:\study\Keil_v5\Arm\ARMCC\bin\fromelf.exe   --bin -o  ..\Project\Objects\STM32F103ZET6.bin ..\Project\Objects\STM32F103ZET6.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\User\HARDWARE\inc;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\IAP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_usart.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../Libraries/FWlib/src/: stm32f10x_flash.c
  group DOC
    ../Doc/: readme.txt
  group HARDWARE
    ../User/HARDWARE/src/: usart.c delay.c key.c led.c stmflash.c
  group IAP
    ../IAP/: iap.c
